require openjdk-7-release-03b147.inc

PR = "${INC_PR}.0"

ICEDTEA = "icedtea-2.1"

SRC_URI[iced.md5sum] = "60395bbd1e2820c4a35e61c80330df14"
SRC_URI[iced.sha256sum] = "8492920dccae8b76bcb41f91f8d98b2dc619380531a679f1f9ea4e166ad02ec6"
